Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_3/temp/tmp_3596_3_wehTX/format_0/429-1.ifc
Time: 2023-02-13T14:18:08
Made in: PARTsolutions

# IfcProject, 429-1
Description: Superplan

# IfcDiscreteAccessory, 429-1
In: BUILDING
Description: 429-1
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 429-1
ePset_PARTsolutions - NB: 429-1; NN: Superplan; NT: Superplan; NBSYN: $PRODID.; LINA: 429-1; CATALOG: Kaldewei; PRODID: 429-1; DESCRIPTION_SHORT: The floor-level Superplan Xxl shower trays are the new size in the bathroom. This is because it is finally possible to experience exclusive showering pleasure in an unusual format. Like no other floor-level shower tray, the Superplan Xxl extends the freedom of movement and of course also gives the room for two to shower. Like its smaller sister, the Superplan Xxl is also available in numerous different sizes.; DESCRIPTION_LONG: New shower size; EDGE_WIDTH_E5: 50.0; INSTALLATION_VARIANT_DW: floorlevelsuitable; OUTER_LENGTH_A1: 900.0; OUTLETPOSITION: cornerdrain; INNER_LENGTH_A5: 790.0; CARRIER_VALANCE: no; OUTER_FORM_DW: quadrangular; INNER_WIDTH_B5: 1290.0; EDGE_HEIGHT_C4: 32.0; OUTER_RADIUS_R1: 12.0; DISTANCE_BATHEDGE_TO_MID_DRAINHOLE_F2: 200.0; DISTANCE_BATHEDGE_TO_MID_DRAINHOLE_F3: 200.0; DEPTH_INNER_C1: 43.0; DIAMETER_DRAINHOLE_F9: 90.0; OUTER_WIDTH_B1: 1400.0; EDGE_WIDTH_E10: 50.0; EF000010: Universal; EF000051: Rectangular; EF020814: false; EF025058: false; EF020363: false; EF002169: -; EF000386: 2,9; EF020621: 12,0; EF001438: 900,0; EF000008: 1400,0; EF000040: 32,0; EF001131: 43,0; EF022185: false; EF025073: false; EF025060: false; EF025074: -; EF000007: Beige; EF024897: Glossy; EF025075: false; EF020710: 90,0; EF025068: true; EF025076: false; EF023789: true; EF000139: Enamelled
